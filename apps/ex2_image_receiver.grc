options:
  parameters:
    author: Thomas Ganley
    description: SDR for the S band transmitter
    generate_options: qt_gui
    id: ex2_image_receiver
    output_language: python
    title: Ex-Alta 2 Image Receiver
  states: {}

blocks:
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: '80'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_cc_0
  id: variable_cc_decoder_def
  parameters:
    framebits: '80'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: lowpass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 400e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 40e3
    win: firdes.WIN_HAMMING
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '2200'
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: nfilts
    ntaps: 11*samp_per_sym*nfilts
    samp_rate: nfilts
    sym_rate: 1.0/float(samp_per_sym)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: syncword
  id: variable
  parameters:
    value: '"0101010101111110"'
  states: {}
- name: variable_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/thomas/repos/ex2_sdr/samples/samp_rate_2M_photo_data_finalpacket_2
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleave_0_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1j
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.010'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '5e-3'
    max_dev: '1e-3'
    osps: '1'
    sps: samp_per_sym
    taps: rrc_taps
    type: ccf
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_cc_0
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_cc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 500e3
    decim: '1'
    samp_rate: samp_rate
    taps: lowpass_taps
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: satellites_descrambler308_0
  id: satellites_descrambler308
  parameters: {}
  states: {}
- name: satellites_descrambler308_0_0
  id: satellites_descrambler308
  parameters: {}
  states: {}
- name: satellites_file_receiver_0
  id: satellites_file_receiver
  parameters:
    path: /home/thomas/repos/ex2_sdr/samples/
    receiver: k2sat
  states: {}
- name: satellites_k2sat_deframer_0
  id: satellites_k2sat_deframer
  parameters: {}
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-3'
    reference: '0.5'
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: packet_len
    sync: syncword
    threshold: '0'
  states: {}
- name: satellites_sync_to_pdu_packed_0_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: packet_len
    sync: syncword
    threshold: '0'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_complex_to_float_0_0, '0', blocks_interleave_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_interleave_0_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_interleave_0, '0', fec_extended_decoder_0, '0']
- [blocks_interleave_0_0, '0', fec_extended_decoder_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_costas_loop_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_diff_decoder_bb_0, '0', satellites_descrambler308_0, '0']
- [digital_diff_decoder_bb_0_0, '0', satellites_descrambler308_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_complex_to_float_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [fec_extended_decoder_0, '0', digital_diff_decoder_bb_0, '0']
- [fec_extended_decoder_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_rms_agc_0, '0']
- [satellites_descrambler308_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [satellites_descrambler308_0_0, '0', satellites_sync_to_pdu_packed_0_0, '0']
- [satellites_k2sat_deframer_0, out, satellites_file_receiver_0, in]
- [satellites_rms_agc_0, '0', digital_costas_loop_cc_0, '0']
- [satellites_sync_to_pdu_packed_0, out, satellites_k2sat_deframer_0, in]
- [satellites_sync_to_pdu_packed_0_0, out, satellites_k2sat_deframer_0, in]

metadata:
  file_format: 1
