options:
  parameters:
    author: Thomas
    description: FSK Receiver
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Demodulation
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: centering_constant
  id: variable
  parameters:
    value: '0'
  states: {}
- name: centre_freq
  id: variable
  parameters:
    value: 140e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: signalsource_freq
  id: variable
  parameters:
    value: 195.3e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: signalsource_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: centering_constant
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: 4M_received(Feb11)
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: 4M_filtered_demod
    type: float
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: 4M_bits
    type: byte
  states: {}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: 4M_baudrate_finder
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.1'
    gain_omega: '0.01'
    mu: '0'
    omega: '16.66'
    omega_relative_limit: '0.01'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 50e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: baud_rate
    decim: '100'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: baud_rate/2
    win: firdes.WIN_HAMMING
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: '0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_file_sink_3, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_file_sink_1, '0']
- [blocks_add_const_vxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_2, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_1, '0', blocks_add_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
