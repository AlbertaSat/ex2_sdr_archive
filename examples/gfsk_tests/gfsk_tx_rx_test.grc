options:
  parameters:
    author: KSK
    generate_options: qt_gui
    id: gfsk_tx_test
    output_language: python
    title: GFSK Tx Test
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '19200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate * sps
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: g_out.bin
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/knud/Development/ex2_sdr/examples/gfsk_tests/g.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '1'
    samples_per_symbol: sps
    sensitivity: '1.0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 150e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_tx
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Set the file source path to wherever g.bin lives
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '500'
    srate: samp_rate
    stemplot: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_tx
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
